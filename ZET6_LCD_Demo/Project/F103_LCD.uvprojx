# Keil uVision project F103_LCD.uvprojx, settings and files
target F103_LCD (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103_LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,
  c include: ..\Main;..\Core;..\Driver;..\SDK\CMSIS\Device\ST\STM32F1xx\Include;..\SDK\CMSIS\Include;..\SDK\STM32F1xx_HAL_Driver\Src;..\SDK\STM32F1xx_HAL_Driver\Inc;..\LCD;..\Driver\OLED
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../Main/: main.c
  group Core
    ../Core/: stm32f1xx_it.c stm32f1xx_clk.c system_stm32f1xx.c stm32f1xx_hal_conf.h startup_stm32f103xe.s
  group Driver
    ../Driver/: driver_usart.c driver_timer.c driver_fsmc.c driver_lcd.c driver_ili9488.c
    ../Driver/OLED/: OLED.c OLED.h OLED_Font.h
  group SDK
    ../SDK/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_fsmc.c
